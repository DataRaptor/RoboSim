# Keil uVision project Compiler.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Compiler +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.cpp Scratch.cpp Scratch.h SmartCat.h Track1.h Track2.h botconfig.cpp botconfig.h Syntax.cpp Syntax.h Track1.cpp
  group Compiler
    ./: Compiler.cpp Compiler.h Instructions.cpp Instructions.h VirtualMachine.cpp VirtualMachine.h ScriptProcessor.cpp ScriptProcessor.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
