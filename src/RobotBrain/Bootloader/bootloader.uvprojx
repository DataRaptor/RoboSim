# Keil uVision project bootloader.uvprojx, settings and files
target Bluepill (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Bootloader;..\Common;.\Karnel;.\Peripherals;.\Peripherals\USB;.\Peripherals\ADC;.\Peripherals\EXTI;.\Peripherals\FLASH;.\Peripherals\GPIO;.\Peripherals\PWM;.\Peripherals\TIM;.\Peripherals\USART;.\Peripherals\RCC;.\Framework;.\Framework\Cryptography;.\Framework\Communication;.\Framework\String;.\Karnel\Protocol;.\Karnel\Protocol\Response;.\Communication;.\Communication\Modules;.\Communication\Protocol;.\Bootloader
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Startup
    ./: main.c blueberry.h ApiFunctions.c ApiFunctions.h
    ../Common/: BlueberryAPI.h
  group Peripherals
    ./Peripherals/: Common.c
    ./Peripherals/RCC/: SYSCLK.c SYSCLK.h
    ./Peripherals/GPIO/: GPIO.c
    ./Peripherals/USART/: USART.c
    ./Peripherals/TIM/: TIM.c TIM.h
    ./Peripherals/EXTI/: EXTI.c EXTI.h
    ../Common/: FLASH.h FLASH.c
  group USB
    ./Peripherals/USB/: USB.c callback.c hw_config.c stm32_it.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
  group Bootloader
    ./Bootloader/: AppLauncher.c AppLauncher.h FirmwareUpdate.c FirmwareUpdate.h
  group Communication
    ./Communication/Protocol/: Protocol.c Protocol.h RequestHandler.c RequestHandler.h
  group Modules
    ./Communication/Modules/: BootMod.h BootMod.c CoreMod.h CoreMod.c
  group Settings
    ./: Settings.c Settings.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
