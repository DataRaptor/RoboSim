# Keil uVision project SmartCat.uvprojx, settings and files
target Bluepill (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCat +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Common;..\SmartcatCore;.\Modules;.\Program;.\Program\Brain;.\Program\Controller;.\Program\IRArray;.\Program\LineAnalyzer;.\Peripheral;.\Peripheral\Buzzer;.\Peripheral\ColorSensor;.\Peripheral\Encoder;.\Peripheral\SonarSensor
  memory RVCT4: ROM 0x8006000 size 0x7800
  memory RVCT9: RAM 0x20001800 size 0x2800
  group Startup
    ./: main.c SmartCat.h ApiFunctions.c ApiFunctions.h
    ../Common/: TitanAPI.h SmartCatAPI.h
  group Brain
    ./Program/Brain/: Actions.c Actions.h Planner.c Planner.h
  group IRArray
    ./Program/IRArray/: IRArray.c IRArray.h
  group LineAnalyzer
    ./Program/LineAnalyzer/: LineAnalyzer.c LineAnalyzer.h
  group Controller
    ./Program/Controller/: PIDController.c PIDController.h
  group Modules
    ./Modules/: SensorTest.c SensorTest.h Simulator.c Simulator.h RemoteControl.c RemoteControl.h
  group Peripheral
    ./Peripheral/Buzzer/: Buzzer.c Buzzer.h
    ./Peripheral/Encoder/: Encoder.c Encoder.h
    ./Peripheral/SonarSensor/: Sonar.c Sonar.h
    ./Peripheral/ColorSensor/: ColorSensor.c ColorSensor.h
  group Lib
    ../Common/: CatLib.h CatLib.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
