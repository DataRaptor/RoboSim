# Keil uVision project TitanOS.uvprojx, settings and files
target Bluepill (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCatOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\TitanOS;..\Common;.\Karnel;.\Modules;.\Peripherals;.\Peripherals\ADC;.\Peripherals\EXTI;.\Peripherals\FLASH;.\Peripherals\GPIO;.\Peripherals\I2C;.\Peripherals\PWM;.\Peripherals\RCC;.\Peripherals\TIM;.\Peripherals\USART;.\Peripherals\USB;.\Framework;.\AppLauncher;.\Com\Protocol;.\Com
  memory RVCT4: ROM 0x8004000 size 0x2800
  memory RVCT9: RAM 0x20000c00 size 0xc00
  group Startup
    ./: main.c titanos.h ApiFunctions.c ApiFunctions.h BoardSupport.c BoardSupport.h
    ../Common/: TitanAPI.h BlueberryAPI.h
  group Peripherals
    ./Peripherals/ADC/: ADC.c ADC.h
    ./Peripherals/EXTI/: EXTI.c EXTI.h
    ./Peripherals/FLASH/: FLASH.h
    ./Peripherals/GPIO/: GPIO.h GPIO.c
    ./Peripherals/PWM/: PWM.c PWM.h
    ./Peripherals/RCC/: SYSCLK.h
    ./Peripherals/TIM/: TIM.h TIM.c
    ./Peripherals/USART/: USART.h
    ./Peripherals/: Common.c Common.h
  group Karnel
    ./Karnel/: Debug.c Debug.h EventTimer.c EventTimer.h Stopwatch.c Stopwatch.h TimeDelay.c TimeDelay.h
  group AppLauncher
    ./AppLauncher/: AppLauncher.c AppLauncher.h
  group Com
    ./Com/Protocol/: Protocol.c Protocol.h RequestHandler.c RequestHandler.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
